<?xml version="1.0" encoding="iso-8859-1"?>



<workspace>

  <project>

    <path>$WS_DIR$\BAT_MONi2c.ewp</path>

  </project>

  <batchBuild/>

</workspace>